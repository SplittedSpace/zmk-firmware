## app/dts/bindings/behaviors/zmk,behavior-indicators.yaml
```yaml
description: Battery control Behavior

compatible: "zmk,behavior-indicators"

include: one_param.yaml
```
